## linux-6.8/fs/evfs/Kconfig
```kconfig
config FS_EVFS
    bool "Extended VFS"
    default n
    help
        Enable Extended VFS
```
